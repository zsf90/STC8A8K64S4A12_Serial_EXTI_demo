# Keil uVision project hello.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8A8K64S4A12 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: hello +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Inc
  group Lib
    ./Lib/: STARTUP.A51
  group Src
    ./Src/: main.c delay.c led.c key.c uart.c
  group Inc
    ./Inc/: delay.h key.h led.h public.h uart.h
